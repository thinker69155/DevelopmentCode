<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\great led.ewp</path>
  </project>
  <batchBuild />
</workspace>
