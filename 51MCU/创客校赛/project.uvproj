# Keil uVision project project.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\创客校赛;.\Listings
  asm include: ..\创客校赛
  group Source Group 1
    ./: main.c calculator.h MatrixKey.c MatrixKey.h delay.c delay.h LCD1602.c LCD1602.h garbage.c compute.c compute.h
