# Keil uVision project project.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\计算器
  group Source Group 1
    ./: main.c timer.c lcd1602.c lcd1602.h keyboard.h keyboard.c calculator.h calculator.c delay.c delay.h globalvars.h globalvars.c display.c display.h
