# Keil uVision project project.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h delay.c delay.h see_lcd1602.c see_lcd1602.h key.c key.h globalvars.c globalvars.h show.c show.h modeswitch.c modeswitch.h handlemode.c handlemode.h timeupdate.c timeupdate.h timer.c timer.h OLED_Font.h
